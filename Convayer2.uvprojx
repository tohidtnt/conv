# Keil uVision project Convayer2.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1342FBD48 NXP
  pack: Keil.LPC1300_DFP.1.1.0
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Convayer2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: main.c motormove.c pwm.c adc.c satus.c sensor.c timer32B1.c timer32B0.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
